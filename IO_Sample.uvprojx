# Keil uVision project IO_Sample.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IO_Sample +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: .\system\delay;.\system\sys;.\system\usart;.\hardware;.\system\gpio;.\system\smartcard;.\system\uart;.\system\irda;.\system\lin
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group system
    ./system/delay/: delay.c
    ./system/sys/: sys.c
    ./: startup_stm32f10x_hd.s
    ./system/gpio/: gpio.c
    ./system/uart/: uart.c
    ./system/smartcard/: smard_card.c
    ./system/irda/: irda.c
    ./system/lin/: lin.c
  group user
    ./: io_sample.c
  group hardware
    ./hardware/: led.c beep.c button.c
